options:
  parameters:
    author: castano_cortes
    category: '[Modulos_L2BG2]'
    copyright: uis
    generate_options: hb
    id: EnvolventeComplejaPM
    output_language: python
    title: Envolvente Compleja PM L1BG2
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud de portadora
    type: eng_float
    value: '0.1'
  states: {}
- name: Kp
  id: parameter
  parameters:
    label: coeficiente_de_modulacion_Pm
    type: eng_float
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Kp
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: m(t)
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0, '0']
- [blocks_transcendental_0, '0', blocks_float_to_complex_0, '0']
- [blocks_transcendental_0_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
