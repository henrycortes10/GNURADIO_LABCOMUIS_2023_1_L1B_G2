options:
  parameters:
    generate_options: qt_gui
    id: Modulacion_de_amplitud
    output_language: python
    title: Modulación de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora (Ac)
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje(Am)
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora (fc)
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje (fm)
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/32
  states: {}
- name: CalculoPotenciaL1B_0
  id: CalculoPotenciaL1B
  parameters:
    l_vect: '1024'
  states: {}
- name: ModuladorAML1BG1_0
  id: ModuladorAML1BG1
  parameters:
    Ac: Ac
    ka: Ka
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '40000'
    interp: '200000'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorAML1BG1_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAML1BG1_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAML1BG1_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', CalculoPotenciaL1B_0, '0']
- [rational_resampler_xxx_0, '0', ModuladorAML1BG1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
