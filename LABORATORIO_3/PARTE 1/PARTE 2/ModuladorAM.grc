options:
  parameters:
    author: Cortes_Castano
    category: '[Modulos_LIBG1]'
    copyright: Cortes_Castano
    generate_options: hb
    id: ModuladorAM_L1B
    output_language: python
    title: ModuladorAM_L1B
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Ac
  id: parameter
  parameters:
    label: Amplitud de portadora
    value: '0'
  states: {}
- name: Ka
  id: parameter
  parameters:
    label: Parameter Ka
    type: eng_float
    value: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ka
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: s(t)
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: m(t)
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', pad_sink_1, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
